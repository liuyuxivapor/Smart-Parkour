# Keil uVision project code.uvprojx, settings and files
target code (ARM-ADS)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IROM(0x00000000,0x00400000) IRAM(0x20000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: code +hex
  AfterMake: fromelf -cvf .\code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\code.axf -o code.txt
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group Sources
    ./: main.c code_def.c lcd.c systick.c keyboard.c gyroscope.c
  group Include
    ./: lcdfont.h code_def.h gyroscope.h
  group Startup
    ./: startup_cmsdk_cm0.s
